# IAR project 3WAY_Solenoid_All.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: rugbyPro IndieSemi rugbyPro
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES; _UNICK_SOL_
  ICCARM.CCIncludePath2: inc; drivers; drivers\studio; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; Function_Blocks\ColorMixingTask; usr\; usr\common; usr\library; usr\leds; lib\downloader\inc; library_unick; library_unick\Library_Sol; library_unick\Library_Sol\src; library_unick\Library_Sol\inc; library_unick\Library_Sol\lib; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rugby_cl_app.bin
  ILINK.IlinkOutputFile: rugby_cl_app.out
  ILINK.IlinkIcfFile: 3WAY_App.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    usr/: main.c main.h
  group applications/config
    usr/common/: appConfig.h
  group applications/include
    usr/common/: isrfuncs.h linslaveTask.h measureTask.h pdsTask.h systemInit.h taskManager.h
    usr/library/: linstackTask.h softTimerTask.h
  group applications/src
    usr/common/: measureTask.c pdsTask.c
  group crc/include
    usr/common/: crc32.h
  group crc/src
    usr/common/: crc32.c
  group drivers/core/inc
    drivers/core/inc/: flash_sfrs.h systick_sfrs.h verne.h
  group drivers/core/src
    drivers/core/src/: cstartup_M.c low_level_init.c
  group drivers/hal/inc
    drivers/hal/inc/: adc_device.h atomic.h clock_device.h errno.h flash_device.h gpio_device.h hwProtection.h lin_device.h pmu_device.h pwm_device.h pwmAux_device.h spi_device.h systick_device.h timer_device.h uart_device.h wdt_device.h
  group drivers/hal/src
    drivers/hal/src/: adc_device.c buck_device.c clock_device.c flash_device.c gpio_device.c hwProtection.c lin_device.c pmu_device.c pwm_device.c pwmAux_device.c spi_device.c systick_device.c timer_device.c uart_device.c wdt_device.c
  group drivers/hdf/inc
    drivers/hdf/sfrs/: adc_sfr.h bte_sfr.h buck_trim_sfr.h buckctrl_sfr.h crga_sfr.h evthold_sfr.h flash_sfr.h gpio_sfr.h ioctrla_sfr.h linm_sfr.h lins_sfr.h pmua_sfr.h pwm_aux_sfr.h pwm_sfr.h rugby_cl_sfr.h spi_sfr.h sysctrla_sfr.h timer0_sfr.h timer1_sfr.h timer2_sfr.h uart_sfr.h wdt1_sfr.h wdta_sfr.h wica_sfr.h
    drivers/hdf/: rugby_cl.h
  group drivers/hwcfg/inc
    drivers/hwcfg/inc/: hwcfg.h
  group drivers/hwcfg/src
    drivers/hwcfg/src/: hwcfg.c
  group drivers/studio
    drivers/studio/: getchar.c putchar.c
  group Libary_Sol/inc
    library_unick/Library_Sol/inc/: Diagnosis.h lin.h lin_cfg.h lin_hw_cfg.h linsNodeCfgIdentify.h MotorControlApi.h MotorControlDriver.h
  group Libary_Sol/src
    library_unick/Library_Sol/src/: Diagnosis.c lin_cfg.c linSlaveTask.c linslaveTask_Private.c linsNodeCfgIdentify.c MotorControlApi.c MotorControlDriver.c
  group library
    library_unick/Library_Sol/lib/: LinStackTask_RugbyPro.a
    usr/library/: SoftTimerTask_RugbyPro.a
  group tasks
    usr/common/: systemInit.c taskManager.c
